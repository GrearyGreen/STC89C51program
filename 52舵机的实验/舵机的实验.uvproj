# Keil uVision project 舵机的实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 舵机的实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 舵机的实验.c MG90S.c
