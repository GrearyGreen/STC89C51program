# Keil uVision project 红外控制数码管显示.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 红外控制数码管显示
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 红外控制数码管显示.c
