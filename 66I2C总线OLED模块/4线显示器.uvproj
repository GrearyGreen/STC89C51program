# Keil uVision project 4线显示器.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 4线显示器 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 4线显示器.c
    ./Oled12864_SRC/: codetab.c IIC.c OLED_12864.c
