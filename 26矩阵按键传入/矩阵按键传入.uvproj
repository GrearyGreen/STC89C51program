# Keil uVision project 矩阵按键传入.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 矩阵按键传入
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 矩阵按键传入.c
